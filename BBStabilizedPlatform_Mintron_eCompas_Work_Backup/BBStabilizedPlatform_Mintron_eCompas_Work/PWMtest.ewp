# IAR project PWMtest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F230H5QR TexasInstruments LM4F230H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F230H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWMtest.srec
  ILINK.IlinkOutputFile: PWMtest.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\examples\TexasInstruments\Stellaris\boards\ek-lm4f230H5QR\BBStabilizedPlatform_Mintron\uart_echo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ewarm; PART_LM4F230H5QR; TARGET_IS_BLIZZARD_RA1
  group Header Files
    ./: A3906.h bluebird.h bma180.h comproc.h filter3.h GPIOhandler.h Interpret.h ITG3200.h Led.h MasterI2C.h reg.h rmb20d01.h Stabilize.h SysTick.h uart_echo.h utilities.h
  group Libraries
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
  group Source Files
    ./: A3906.c BMA180.c cbuf.c comproc.c encoder.c filter3.c GPIOhandler.c Interpret.c ITG3200.c Led.c MAG3110.c MasterI2C.c PWMtest.c reg.c rmb20d01.c Script.c Stabilize.c startup.c SysTick.c uart_echo.c utilities.c
