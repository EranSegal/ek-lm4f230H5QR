# IAR project StabilizedPlatform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F230H5QR TexasInstruments LM4F230H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; stabilizition; PART_LM4F230H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..; ..; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: StabilizedPlatform.srec
  ILINK.IlinkOutputFile: StabilizedPlatform.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ewarm; stabilizition; PART_LM4F230H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCOptLevel: 3
  group Header Files
    ./: A3906.h bluebird.h bma180.h comproc.h encoder.h filter3.h Interpret.h ITG3200.h Led.h MAG3110.h MasterI2C.h modeid.h mtype.h pins.h reg.h rmb20d01.h Stabilize.h SysTick.h uart_echo.h utilities.h
  group Libraries
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/sensorlib/ewarm/Exe/: sensorlib.a
  group Source Files
    ./: A3906.c BMA180.c comproc.c encoder.c filter3.c GPIOhandler.c Interpret.c ITG3200.c Led.c MAG3110.c MasterI2C.c reg.c rmb20d01.c Stabilize.c StabilizedPlatform.c startup.c SysTick.c uart_echo.c utilities.c
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/utils/: uartstdio.c
