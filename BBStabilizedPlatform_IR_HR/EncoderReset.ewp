# IAR project EncoderReset.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: A3906.c A3906.h bluebird.h Console.c Console.h EncoderReset.c GPIOhandler.c GPIOhandler.h ministartup.c rmb20d01.c rmb20d01.h SysTick.c SysTick.h utilities.c utilities.h
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm/Exe/: driverlib.a
