# IAR project PWMtest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F230H5QR TexasInstruments LM4F230H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F230H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..; ..; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWMtest.srec
  ILINK.IlinkOutputFile: PWMtest.out
  ILINK.IlinkIcfFile: C:\Program Files\IAR Systems\Embedded Workbench 6.0\arm\examples\TexasInstruments\Stellaris\boards\ek-lm4f232\BBStabilizedPlatform_Night\uart_echo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Header Files
    ./: A3906.h bluebird.h bma180.h encoder.h filter3.h gpiohandler.h ITG3200.h Led.h MAG3110.h MasterI2C.h pins.h reg.h rmb20d01.h Stabilize.h SysTick.h utilities.h
  group Libraries
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm/Exe/: driverlib.a
  group Source Files
    ./: A3906.c BMA180.c cbuf.c encoder.c filter3.c GPIOhandler.c ITG3200.c Led.c MAG3110.c MasterI2C.c ministartup.c PWMtest.c reg.c rmb20d01.c Script.c Stabilize.c SysTick.c uart_echo.c utilities.c
