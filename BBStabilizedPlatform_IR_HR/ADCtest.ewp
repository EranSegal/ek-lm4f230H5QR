# IAR project ADCtest.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADCtest.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ADCtest.c Console.c Console.h GPIOhandler.c ministartup.c rmb20d01.c rmb20d01.h SysTick.c SysTick.h
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm/Exe/: driverlib.a
